# Keil uVision project Project.uvprojx, settings and files
target STM32F303CCT6 (6180000::V6.18::ARMCLANG)
  device: STM32F303CCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F303CCT6
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=7 wLevel=3
  c define: USE_STDPERIPH_DRIVER,STM32F303xC,USE_STM32303C_EVAL
  c include: ..\;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F30x\Include;..\Libraries\STM32F30x_StdPeriph_Driver\inc;..\Libraries\STM32F30x_I2C_CPAL_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  link misc: --diag_suppress=L6329
  group STM32F30x_StdPeriph_Driver
    ../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_comp.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_hrtim.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c
  group User
    ../: stm32f30x_it.c system_stm32f30x.c main.c startup_stm32f303xc.s stm32f30x.h stm32f30x_conf.h stm32f30x_it.h my_global.c
    ../MySPI/: myspi.c
    ../TIM4/: my_tim4_delay.c
    ../AD9833/: AD9833.c
    ../HD44780/: hd44780.c
    ../USART/: myusart.c
    ../MyADC/: myadc.c
    ../encoder/: myencoder.c
    ../afc/: myafc.c
software components: CMSIS:CORE 5.6.0
